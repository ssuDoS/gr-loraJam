options:
  parameters:
    author: ziree
    cmake_opt: '-DCMAKE_BUILD_TYPE=RelWithDebInfo'
    generate_options: no_gui
    id: lora_jamming_one_sf
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: Att_dB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Att_dB_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Tx_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: center_freq_2
  id: variable
  parameters:
    value: 433.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '7'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: loraJam_frameDetect_0
  id: loraJam_frameDetect
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    os_factor: int(samp_rate/bw)
    preamb_len: '8'
    sf: sf
    sync_word: '18'
  states: {}
- name: loraJam_jammer_0
  id: loraJam_jammer
  parameters:
    bw: bw
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: loraJam_trigger_0
  id: loraJam_trigger
  parameters:
    cr1_symb_cnt: '1'
    cr2_symb_cnt: '0'
    cr3_symb_cnt: '0'
    cr4_symb_cnt: '0'
    incl_cr0: 'False'
    verbose: 'False'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"addr=192.168.10.2"'
    gain0: Tx_gain
    len_tag_name: '"frame_len"'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bw
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '"addr=192.168.10.2"'
    gain0: '0'
    minoutbuf: 2**sf<<2
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [loraJam_frameDetect_0, detect_out, loraJam_trigger_0, msg_in]
- [loraJam_jammer_0, '0', uhd_usrp_sink_0_0, '0']
- [loraJam_trigger_0, '0', loraJam_jammer_0, '0']
- [loraJam_trigger_0, '1', blocks_null_sink_0_0, '0']
- [loraJam_trigger_0, '2', blocks_null_sink_0, '0']
- [loraJam_trigger_0, '3', blocks_null_sink_0_0_0, '0']
- [loraJam_trigger_0, '4', blocks_null_sink_0_0_0_0, '0']
- [loraJam_trigger_0, '5', blocks_null_sink_0_0_0_1, '0']
- [uhd_usrp_source_0_0, '0', loraJam_frameDetect_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
